# Keil uVision project Project.uvproj, settings and files
target Template (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Hardware;..\User\System;..\User
  group User
    ../User/: main.c readme.txt
